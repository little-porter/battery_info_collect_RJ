# Keil uVision project cjtl.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cjtl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1,__CC_ARM
  c include: .\App;.\CMSIS;.\Lib\inc;.\Hardware;C:\keil_v5\ARM\ARMCLANG\include;.\Console;.\System
  memory RVCT4: ROM 0x8000000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group App
    ./App/: main.c stm32f30x_it.c mcu_init.c arm_cortexM4lf_math.lib config.h gas.c
  group CMSIS
    ./CMSIS/: system_stm32f30x.c startup_stm32f30x.s
  group Lib
    ./Lib/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Hardware
    ./Hardware/: adc.c can.c dac.c GZP6816D.c i2c_gpio.c gxht30.c flash_bsp.c led.c timer.c modbus.c uart.c fft.c
  group console
    ./Console/: cmd_list.c console.c fifo.c serial.c
  group System
    ./System/: sysTask.c system.c systick.c
